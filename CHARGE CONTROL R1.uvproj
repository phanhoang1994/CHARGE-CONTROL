# Keil uVision project CHARGE CONTROL R1.uvproj, settings and files
target PROGRAM (ARM-ADS)
  device: TM4C123AE6PM Texas Instruments
  cpu: IROM(0x00000000,0x020000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: CHARGE CONTROL R1 +hex
  c flags: Optim=3 wLevel=2
  c define: rvmdk PART_TM4C123AE6PM TARGET_IS_TM4C123_RB1
  c include: .\ti\TivaWare_C_Series-2.1.4.178
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group inc
    ./inc/: adc.h display.h function.h global.h sysclock.h uart4.h
  group Src
    ./src/: adc.c display.c function.c sysclock.c uart4.c startup_rvmdk.S main.c
  group Lib
    ./ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
